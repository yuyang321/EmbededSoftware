# Keil uVision project masslink.uvprojx, settings and files
target masslinkV1.0.0 (ARM-ADS)
  device: STM32F105RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: masslink +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F105RB
  c include: ..\procode\gos;..\procode\user;..\procode\bsp;.\RTE
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\config\masslinkV001.sct
  group gos
    ../procode/gos/: glist.c gtimer.c gpipe.c retarget.c gevent.c
  group user
    ../procode/user/: gboot.c system_stm32f10x.c gmain.c girq.s stm32f10x_it.c gusertask.c
  group bsp
    ../procode/bsp/: gusart.c gbsp.c
software components: CMSIS:CORE 5.1.1, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
